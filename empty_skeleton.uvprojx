# Keil uVision project empty_skeleton.uvprojx, settings and files
target Target 1 (6240000::V6.24::ARMCLANG)
  device: STM32F103ZC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: empty_skeleton
  c flags: Optim=4 uC99=1 v6Lang=3 v6LangP=3
  c include: .\Headers
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Sources
    ./sources/: main.c SystemInit.c debug.c clock.h debug.h adc.c adc.h dac.c dac.h tests.c tests.h extclk.c extclk.h audio.c audio.h
    ./Sources/: capture.c capture.h startup_stm32f10x_hd.s
    ./Sources/spi/: clock_spi.c clock_spi.h
  group Headers
    ./headers/: stm32f103xe.h system_stm32f1xx.h
  group LCD
    ./LCD/: font5x7.c lcd_grph.c lcd_hw.c lcd_ili9341.c
  group UI
    ./Sources/ui/: rate_ctrl.c rate_ctrl.h touch.c touch.h ui.c ui.h mixer.c mixer.h fft.c fft.h
  group Sampling
    ./Sources/Sampling/: sampling.c sampling.h
software components: CMSIS:CORE 6.4.0
